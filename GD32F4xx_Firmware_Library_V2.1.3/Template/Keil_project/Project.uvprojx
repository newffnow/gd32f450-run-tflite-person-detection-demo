# Keil uVision project Project.uvprojx, settings and files
target GD32F4XX (6160000::V6.16::ARMCLANG)
  device: GD32F450ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Utilities;..\..\Firmware\CMSIS;..\..\Template;..\..\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\Utilities\Third_Party\tensorflow_keil;..\..\Utilities\Third_Party\tensorflow_keil\third_party\flatbuffers\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rtc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_gpio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_trng.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Utilities
    ../../Utilities/: gd32f450i_eval.c
  group Doc
    ../: readme.txt
  group lib
    ../../Utilities/Third_Party/tensorflow_keil/lflite_project/Objects/: tflite.lib
  group person_detection
    ../../Utilities/Third_Party/tensorflow_keil/tensorflow/lite/micro/examples/person_detection/: detection_responder.cc image_provider.cc main.cc main_functions.cc model_settings.cc person.cc
  group models
    ../../Utilities/Third_Party/tensorflow_keil/tensorflow/lite/micro/models/: person_detect_model_data.cc
software components: Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
